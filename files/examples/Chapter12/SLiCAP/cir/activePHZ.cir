"Active phantom-zero compensation"
* gnetlist -q -g spice-noqsi -o activePHZ.net activePHZ.sch
* SPICE file generated by spice-noqsi version 20170819
* Send requests or bug reports to jpd@noqsi.com
V1 2 0 V value=0 dc=0 dcvar=0 noise=0
R2 4 0 82
R1 1 3 1k
O2 out 3 1 0 AD8610
O1 2 1 out 0 AD8610_A0
I1 0 out I value=0 dc=0 dcvar=0 noise=0
C3 3 4 2.7n
C1 out 0 10u
.param A_0=300k
.end
