"ADC reference driver compensated"
* gnetlist -q -g spice-noqsi -o cdrivercompensated.net cdrivercompensated.sch
* SPICE file generated by spice-noqsi version 20170819
* Send requests or bug reports to jpd@noqsi.com
V1 2 0 V value=0 dc=0 dcvar=0 noise=0
R2 out1 out2 r value={R_phz} dcvar=0
R1 2 1 15k
O1 1 out1 out1 0 AD8610
I2 0 out2 I value=0 dc=0 dcvar=0 noise=0
I1 0 out1 I value=0 dc=0 dcvar=0 noise=0
C2 out2 0 10u
C1 1 0 1u
.param R_phz=0.18
.end
