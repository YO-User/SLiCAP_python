"ADC reference driver"
* gnetlist -q -g spice-noqsi -o cdriver.net cdriver.sch
* SPICE file generated by spice-noqsi version 20170819
* Send requests or bug reports to jpd@noqsi.com
V1 2 0 V value=0 dc=0 dcvar=0 noise=0
R1 2 1 15k
O1 1 out out 0 AD8610
C2 out 0 10u
C1 1 0 1u
.end
